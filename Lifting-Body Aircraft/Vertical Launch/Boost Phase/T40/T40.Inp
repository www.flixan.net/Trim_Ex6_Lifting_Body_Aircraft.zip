BATCH MODE INSTRUCTIONS ...............                                                             
Batch for analyzing the Lifting-Body vehicle during launch at t=40 sec after lift-off.
! This batch set creates dynamic models of the Lifting-Body vehicle for control design 
! and simulation purposes. The model is in the body axis. It creates also two additional 
! (pitch and lateral) models for control design using the LQR method. All 13 effectors 
! are used to control the vehicle, which includes: 7 aero-surfaces, and 2 TVC/ Throttling
! engines. The systems are converted to Matlab format in separate files, vehicle_sim.m, etc.
!
Flight Vehicle   : Lifting-Body Aircraft Ascent Trajectory/ T= 40 sec
System Modificat : Lifting-Body Aircraft Ascent Pitch Design Model
System Modificat : Lifting-Body Aircraft Ascent Lateral Design Model
To Matlab Format : Lifting-Body Aircraft Ascent Trajectory/ T= 40 sec
To Matlab Format : Lifting-Body Aircraft Ascent Pitch Design Model
To Matlab Format : Lifting-Body Aircraft Ascent Lateral Design Model
----------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Lifting-Body Aircraft Ascent Trajectory/ T= 40 sec                                         
! This Lifting-Body vehicle model was created by the Trim program during the boost phase at 40 sec 
! after lift-off. The vehicle is controlled by the 7 aero-surfaces plus the 2 TVC engines which are
! also able to throttle. The thrust variation is about a nominal 15,900 (lb) thrust, and it can vary
! +/- 6200 (lb) from nominal thrust. The effectors will be combined with a Kmix matrix.
Body Axes Output, Attitude=Rate Integral, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   554.500       32.1740      0.208960E+08
Moments and products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   11744.8       45216.2       50559.0       0.00000      444.897        0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -17.1967       0.00000      -2.00574    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   0.62          663.500       348.500       13250.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   10.5500       42.6300       0.00000      0.465200    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   1.21000       0.00000      0.999999E-02   0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00000       90.1400       0.00000       0.00000      0.400000E-02   0.00000    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust         45.0000      90.0000                                             
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   300.000       34.0000       15.0000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -16.2000       0.00000      -2.10000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.471063E-01 -0.211574E-03  0.412323E-04   0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000     -0.676920E-02   0.00000     -0.144314E-04   0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.192732E-01 -0.422262E-01   0.00000       0.00000       0.00000       0.00000      0.175782E-04
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000     -0.137884E-01   0.00000     -0.646900      0.468460     -0.321195E-05
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.113380E-01 -0.345480E-02   0.00000     -0.686001E-04 -0.256040     -0.255521E-04   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000      0.358400E-02   0.00000      0.438550     -0.904580      0.811100E-05

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  7   NO TWD  

Control Surface No:  1                                                                     Left Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg): -0.7            30.0000      -30.0000       45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.595500E-02   0.00000     -0.140413E-01  0.816997E-02
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000      -7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.219753E-03  0.182093E-02 -0.245653E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.176087E-02 -0.891200E-03 -0.135013E-02   0.00000       0.00000       0.00000    
Control Surface No:  2                                                                     Right Elevon   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg): -0.7            30.0000      -30.0000      -45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.595500E-02   0.00000     -0.140413E-01  0.816997E-02
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000       7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.219753E-03 -0.182093E-02 -0.245653E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.176087E-02 -0.891200E-03  0.135013E-02   0.00000       0.00000       0.00000    
Control Surface No:  3                                                                     Vert Rudder    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  0.0            30.0000      -30.0000       90.0000       2.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       5.80000       12.0000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.228420E-01   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -33.0000       0.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.238147E-03  0.112253E-02  0.448593E-04   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.706867E-05  0.130000E-04 -0.904800E-03   0.00000       0.00000       0.00000    
Control Surface No:  4                                                                     BFlap Up-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -5.22          10.0000      -50.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.174433E-01   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.553467E-03 -0.289820E-04 -0.210773E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.706867E-03 -0.516600E-03 -0.424133E-04   0.00000       0.00000       0.00000    
Control Surface No:  5                                                                     BFlap Up-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -5.22          10.0000      -50.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.174433E-01   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.553467E-03  0.289820E-04 -0.210773E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.706867E-03 -0.516600E-03  0.424133E-04   0.00000       0.00000       0.00000    
Control Surface No:  6                                                                     BFlap Lo-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   14.48         50.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.261086E-01   0.00000      0.222640E-03  0.149750E-02
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.862267E-03  0.500473E-03 -0.173940E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.289820E-03 -0.580620E-03 -0.220547E-03   0.00000       0.00000       0.00000    
Control Surface No:  7                                                                     BFlap Lo-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   14.48         50.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.261086E-01   0.00000      0.222640E-03  0.149750E-02
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.862267E-03 -0.500473E-03 -0.173940E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.289820E-03 -0.580620E-03  0.220547E-03   0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  2   NO TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Left TVC Eng#1   Gimbaling   Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   15900.0       22100.0    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       5.00000       5.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   60.0000       8.00000      0.700000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -33.5000      -6.00000      -2.20000    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Rght TVC Eng#2   Gimbaling   Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   15900.0       22100.0    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       5.00000       5.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   60.0000       8.00000      0.700000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -33.5000       6.00000      -2.20000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  3
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  X-axis Accelerat.     -17.1967        0.00000       -2.00574    
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.     -17.1967        0.00000       -2.00574    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.     -17.1967        0.00000       -2.00574    
----------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Lifting-Body Aircraft Ascent Pitch Design Model                                         
Lifting-Body Aircraft Ascent Trajectory/ T= 40 sec                                                      
! Extract the Pitch axis subsystem from the stability-axis model to be used for 
! Pitch LQR control design. Include all 7 aero-surface control inputs.
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1  2  3  4  5  6  7  8  9 10 11 12 13
Extract States :   3  4  7  
Extract Outputs:   3  4  7
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Lifting-Body Aircraft Ascent Lateral Design Model
Lifting-Body Aircraft Ascent Trajectory/ T= 40 sec                                                      
! Extract the Lateral axis subsystem from the stability-axis model to be used for 
! Lateral LQR control design. Include all 7 aero-surface control inputs.
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1  2  3  4  5  6  7  8  9 10 11 12 13
Extract States :   1  2  6  8
Extract Outputs:   1  2  6  8
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lifting-Body Aircraft Ascent Trajectory/ T= 40 sec                                                                                    
System
vehicle_sim
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lifting-Body Aircraft Ascent Pitch Design Model                                                                                    
System
Pitch_des
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lifting-Body Aircraft Ascent Lateral Design Model                                                                                    
System
Later_des
----------------------------------------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
