BATCH MODE INSTRUCTIONS ...............                                                             
Batch for analyzing the Transitioning Phase of the Lifting-Body Vehicle at t=1052 sec
! This batch set creates dynamic models for control design and simulations of the lifting-body 
! vehicle during the early re-entry phase where Qbar is very low. It creates a model in the 
! body axis for simulation purposes. It creates also two additional models (pitch and lateral)
! for control design for using the LQR method. All 7 aero-surfaces are used to control the 
! vehicle. 
!
Flight Vehicle   : Lifting-Body Aircraft Hypersonic Descent from Space /T= 1052 sec (Simul Model)
Flight Vehicle   : Lifting-Body Aircraft Hypersonic Descent from Space /T= 1052 sec (Stability Axis)
Mixing Matrix    : Mixing Logic Lifting-Body Aircraft Hypersonic Descent from Space /T= 1052 sec
System Modificat : Lifting-Body Aircraft Hypersonic Pitch Design Model
System Modificat : Lifting-Body Aircraft Hypersonic Lateral Design Model
To Matlab Format : Lifting-Body Aircraft Hypersonic Descent from Space /T= 1052 sec (Simul Model)
To Matlab Format : Lifting-Body Aircraft Hypersonic Pitch Design Model
To Matlab Format : Lifting-Body Aircraft Hypersonic Lateral Design Model
To Matlab Format : Mixing Logic Lifting-Body Aircraft Hypersonic Descent from Space /T= 1052 sec
----------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Lifting-Body Aircraft Hypersonic Descent from Space /T= 1052 sec (Simul Model)
! This Lifting-Body Aircraft Model is created by the Trim program at t=1052 sec trajectory time.
! It uses all 7 aero-surfaces for flight control. The output rates are in the Body-Axis. It will 
! be used for simulations in Simulink
Body Axes Output, Attitude=Euler Angles
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   527.950       32.1740      0.208960E+08
Moments and products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   10800.0       43300.0       49600.0       0.00000       433.000      0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -17.0420       0.00000      -2.03400    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   7.22200       8013.80       172.829       144238.    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  -13.6088      -8.72000      0.100000E-02  -33.2390    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   8.86400       0.00000      0.145654E-01   0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0           8.55500       0.00000       0.0          0.140000E-01   0.00000    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.0000       90.0000                                             
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   300.000       34.0000       15.0000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -16.2000       0.00000      -2.10000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.677030E-01 -0.113649E-02   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000     -0.964260E-02   0.00000     -0.270607E-05   0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.339442     -0.408443E-01   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000     -0.159558E-01   0.00000     -0.603260      0.667660     -0.175717E-05
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.571891E-02 -0.196164E-02   0.00000     -0.570402E-04 -0.190100       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000      0.252780E-02   0.00000      0.301090     -0.993980      0.228541E-05

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  7   NO TWD  

Control Surface No:  1                                                                     Left Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   4.77          30.0000      -30.0000       45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.156700E-02   0.00000     -0.553220E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000      -7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.660867E-03  0.135300E-02 -0.823467E-03   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.606507E-03 -0.315027E-03 -0.153673E-02   0.00000       0.00000       0.00000    
Control Surface No:  2                                                                     Right Elevon   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   4.77          30.0000      -30.0000      -45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.156700E-02   0.00000     -0.553220E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000       7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.660867E-03 -0.135300E-02 -0.823467E-03   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.606507E-03 -0.315027E-03  0.153673E-02   0.00000       0.00000       0.00000    
Control Surface No:  3                                                                     Vert Rudder    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   0.0           30.0000      -30.0000       90.0000       2.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       5.80000       12.0000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.982067E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -33.0000       0.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.229413E-03  0.103773E-02 -0.248180E-03   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.161167E-03 -0.646667E-04 -0.739400E-03   0.00000       0.00000       0.00000    
Control Surface No:  4                                                                     BFlap Up-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -5.36          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.791867E-03   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.711067E-03  0.124413E-03 -0.215153E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.646093E-03 -0.533080E-03 -0.219840E-03   0.00000       0.00000       0.00000    
Control Surface No:  5                                                                     BFlap Up-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -5.36          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.791867E-03   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.711067E-03 -0.124413E-03 -0.215153E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.646093E-03 -0.533080E-03  0.219840E-03   0.00000       0.00000       0.00000    
Control Surface No:  6                                                                     BFlap Lo-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   3.84          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.766400E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.877067E-03  0.355560E-03 -0.186527E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.348493E-03 -0.724533E-03 -0.245287E-03   0.00000       0.00000       0.00000    
Control Surface No:  7                                                                     BFlap Lo-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   3.84          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.766400E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.877067E-03 -0.355560E-03 -0.186527E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.348493E-03 -0.724533E-03  0.245287E-03   0.00000       0.00000       0.00000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  3
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  X-axis Accelerat.     -17.0477        0.00000       -2.03282    
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.     -17.0477        0.00000       -2.03282    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.     -17.0477        0.00000       -2.03282    
----------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Lifting-Body Aircraft Hypersonic Descent from Space /T= 1052 sec (Stability Axis)                             
! This Lifting-Body Aircraft Model is created by the Trim program at t=3000 sec trajectory time.
! It uses all 7 aero-surfaces for flight control. The output rates are in the Stability-Axis and the
! "Turn-Coordination" flag is turned-on. That is, the turn-coordination terms will be included in the
! model. This model will be used to create the pitch and lateral LQR design state-space systems.
!
Stability Output, Attitude=Euler Angles, With Turn Coordination
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   527.950       32.1740      0.208960E+08
Moments and products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   10800.0       43300.0       49600.0       0.00000       433.000      0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -17.0420       0.00000      -2.03400    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   7.22200       8013.80       172.829       144238.    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  -13.6088      -8.72000      0.100000E-02  -33.2390    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   8.86400       0.00000      0.145654E-01   0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0           8.55500       0.00000       0.0          0.140000E-01   0.00000    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.0000       90.0000                                             
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   300.000       34.0000       15.0000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -16.2000       0.00000      -2.10000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.677030E-01 -0.113649E-02   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000     -0.964260E-02   0.00000     -0.270607E-05   0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.339442     -0.408443E-01   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000     -0.159558E-01   0.00000     -0.603260      0.667660     -0.175717E-05
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.571891E-02 -0.196164E-02   0.00000     -0.570402E-04 -0.190100       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000      0.252780E-02   0.00000      0.301090     -0.993980      0.228541E-05

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  7   NO TWD  

Control Surface No:  1                                                                     Left Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   4.77          30.0000      -30.0000       45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.156700E-02   0.00000     -0.553220E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000      -7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.660867E-03  0.135300E-02 -0.823467E-03   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.606507E-03 -0.315027E-03 -0.153673E-02   0.00000       0.00000       0.00000    
Control Surface No:  2                                                                     Right Elevon   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   4.77          30.0000      -30.0000      -45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.156700E-02   0.00000     -0.553220E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000       7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.660867E-03 -0.135300E-02 -0.823467E-03   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.606507E-03 -0.315027E-03  0.153673E-02   0.00000       0.00000       0.00000    
Control Surface No:  3                                                                     Vert Rudder    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   0.0           30.0000      -30.0000       90.0000       2.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       5.80000       12.0000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.982067E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -33.0000       0.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.229413E-03  0.103773E-02 -0.248180E-03   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.161167E-03 -0.646667E-04 -0.739400E-03   0.00000       0.00000       0.00000    
Control Surface No:  4                                                                     BFlap Up-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -5.36          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.791867E-03   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.711067E-03  0.124413E-03 -0.215153E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.646093E-03 -0.533080E-03 -0.219840E-03   0.00000       0.00000       0.00000    
Control Surface No:  5                                                                     BFlap Up-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -5.36          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.791867E-03   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.711067E-03 -0.124413E-03 -0.215153E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.646093E-03 -0.533080E-03  0.219840E-03   0.00000       0.00000       0.00000    
Control Surface No:  6                                                                     BFlap Lo-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   3.84          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.766400E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.877067E-03  0.355560E-03 -0.186527E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.348493E-03 -0.724533E-03 -0.245287E-03   0.00000       0.00000       0.00000    
Control Surface No:  7                                                                     BFlap Lo-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   3.84          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.766400E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.877067E-03 -0.355560E-03 -0.186527E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.348493E-03 -0.724533E-03  0.245287E-03   0.00000       0.00000       0.00000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  3
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  X-axis Accelerat.     -17.0477        0.00000       -2.03282    
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.     -17.0477        0.00000       -2.03282    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.     -17.0477        0.00000       -2.03282    
----------------------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic Lifting-Body Aircraft Hypersonic Descent from Space /T= 1052 sec                                                      Title
! Mixing Logic Matrix for the Lifting-Body Aircraft during Descent at T=1052                                                       Comments
KmixM7a                                                                                                                            Matrix Name
Lifting-Body Aircraft Hypersonic Descent from Space /T= 1052 sec (Simul Model)                                                     Vehicle Data
P-dot Roll  Acceleration About X Axis                                                                                              3-rotational dofs
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
----------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Lifting-Body Aircraft Hypersonic Pitch Design Model                                         
Lifting-Body Aircraft Hypersonic Descent from Space /T= 1052 sec (Stability Axis)                                                      
! Extract the Pitch axis subsystem from the stability-axis model to be used for 
! Pitch LQR control design. Include all 7 aero-surface control inputs.
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1  2  3  4  5  6  7
Extract States :   3  4  7  
Extract Outputs:   3  4  7
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Lifting-Body Aircraft Hypersonic Lateral Design Model
Lifting-Body Aircraft Hypersonic Descent from Space /T= 1052 sec (Stability Axis)                                                      
! Extract the Lateral axis subsystem from the stability-axis model to be used for 
! Lateral LQR control design. Include all 7 aero-surface control inputs.
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1  2  3  4  5  6  7
Extract States :   2  6  8
Extract Outputs:   2  6  8
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lifting-Body Aircraft Hypersonic Descent from Space /T= 1052 sec (Simul Model)                                                                                    
System
vehicle_sim
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lifting-Body Aircraft Hypersonic Pitch Design Model                                                                                    
System
Pitch_des
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lifting-Body Aircraft Hypersonic Lateral Design Model                                                                                    
System
Later_des
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic Lifting-Body Aircraft Hypersonic Descent from Space /T= 1052 sec            
Matrix KmixM7a
----------------------------------------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
