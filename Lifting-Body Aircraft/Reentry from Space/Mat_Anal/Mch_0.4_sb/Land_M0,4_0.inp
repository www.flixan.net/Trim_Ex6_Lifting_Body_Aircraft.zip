BATCH MODE INSTRUCTIONS ...............                                                             
Batch for analyzing the Lifting-Body Vehicle during Approach and Landing, at t=1839 sec.
! This batch set creates dynamic models for control design and simulations of the lifting-body 
! vehicle during the approach and landing phase. During this phase the altitude is controlled
! by pitching and the velocity by the speed-brake. The speed-brake is partially opened (body-flaps
! are at +/- 25 deg). The batch creates a model in the body axis for simulation purposes. 
! It creates also two additional models (pitch and lateral) for control design using the LQR method, 
! and a model with uncertainties for robust analysis. The change in altitude and velocity (phugoid) 
! states are also included in the pitch design. The surfaces mixing matrix has a fourth column 
! for drag-modulation control. All 7 aero-surfaces are used to control the vehicle. 
!
Flight Vehicle   : Lifting-Body Aircraft Landing Phase (Simul Model)
Flight Vehicle   : Lifting-Body Aircraft Landing Phase (Stability Axis)
Flight Vehicle   : Lifting-Body Aircraft Landing Phase (Robust Analysis with 60 Uncert)
Mixing Matrix    : Mixing Logic for Lifting-Body Aircraft Landing Phase
System Modificat : Lifting-Body Aircraft Near Landing, Simulation Model
System Modificat : Lifting-Body Aircraft Landing Phase Pitch Design Model
System Modificat : Lifting-Body Aircraft Landing Phase Lateral Design Model
System Modificat : Lifting-Body Aircraft Near Landing, Pitch Robust Analysis (28 Uncs)
System Modificat : Lifting-Body Aircraft Near Landing, Lateral Robust Analysis (32 Uncs)
To Matlab Format : Lifting-Body Aircraft Near Landing, Simulation Model
To Matlab Format : Lifting-Body Aircraft Landing Phase Pitch Design Model
To Matlab Format : Lifting-Body Aircraft Landing Phase Lateral Design Model
To Matlab Format : Mixing Logic for Lifting-Body Aircraft Landing Phase
To Matlab Format : Lifting-Body Aircraft Near Landing, Pitch Robust Analysis (28 Uncs)
To Matlab Format : Lifting-Body Aircraft Near Landing, Lateral Robust Analysis (32 Uncs)
----------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Lifting-Body Aircraft Landing Phase (Simul Model)
! This Lifting-Body Aircraft Model is created by the Trim program at t=1839 sec trajectory time.
! It uses all 7 aero-surfaces for flight control. The output rates are in the Body-Axis. It will 
! be used for simulations in Simulink
Body Axes Output, Attitude=Euler Angles
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   527.950       32.1740      0.208960E+08
Moments and products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   10800.0       43300.0       49600.0       0.00000       433.000      0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -17.0420       0.00000      -2.03400    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.433000       466.400       199.449       8694.90    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  -1.68420      -7.86800       0.00000      -31.4990    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   8.53100       0.00000      0.178947E-01   0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00000      -33.1330       0.00000       0.00000     -0.800000E-02  0.100000E-02
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust         45.0000      90.0000                                             
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   300.000       34.0000       15.0000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -16.2000       0.00000      -2.10000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.279368E-01 -0.628772E-02 -0.835307E-05   0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000     -0.756440E-02   0.00000     -0.841975E-05   0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.276936     -0.387948E-01   0.00000       0.00000       0.00000       0.00000     -0.149593E-03
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000     -0.109128E-01   0.00000     -0.603260      0.667660      0.313128E-04
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.795947E-02 -0.359662E-02   0.00000     -0.190200E-04 -0.190100     -0.265926E-04   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000      0.212280E-02   0.00000      0.301090     -0.993980      0.409249E-05

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  7   NO TWD  

Control Surface No:  1                                                                     Left Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -3.7           30.0000      -30.0000       45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.169400E-02   0.00000     -0.871020E-02 -0.916866E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000      -7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.202527E-03  0.167813E-02 -0.232000E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.163713E-02 -0.896933E-03 -0.131907E-02   0.00000       0.00000       0.00000    
Control Surface No:  2                                                                     Right Elevon   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -3.7           30.0000      -30.0000      -45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.169400E-02   0.00000     -0.871020E-02 -0.916866E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000       7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.202527E-03 -0.167813E-02 -0.232000E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.163713E-02 -0.896933E-03  0.131907E-02   0.00000       0.00000       0.00000    
Control Surface No:  3                                                                     Vert Rudder    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   0.0           30.0000      -30.0000       90.0000       2.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       5.80000       12.0000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.170533E-01   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -33.0000       0.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.311647E-03  0.152260E-02  0.583573E-04   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.103913E-03  0.120000E-04 -0.114373E-02   0.00000       0.00000       0.00000    
Control Surface No:  4                                                                     BFlap Up-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -14.0          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.376000E-02   0.00000     -0.940133E-02  0.579333E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.363793E-03 -0.250240E-03 -0.115020E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.448873E-03 -0.126773E-03  0.268613E-04   0.00000       0.00000       0.00000    
Control Surface No:  5                                                                     BFlap Up-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -14.0          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.376000E-02   0.00000     -0.940133E-02  0.579333E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.363793E-03  0.250240E-03 -0.115020E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.448873E-03 -0.126773E-03 -0.268613E-04   0.00000       0.00000       0.00000    
Control Surface No:  6                                                                     BFlap Lo-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   15.0          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.405997E-03   0.00000     -0.519187E-02 -0.484100E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.908333E-03  0.594487E-03 -0.129520E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.308907E-03 -0.375247E-03 -0.193687E-03   0.00000       0.00000       0.00000    
Control Surface No:  7                                                                     BFlap Lo-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   15.0          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.405997E-03   0.00000     -0.519187E-02 -0.484100E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.908333E-03 -0.594487E-03 -0.129520E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.308907E-03 -0.375247E-03  0.193687E-03   0.00000       0.00000       0.00000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  3
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  X-axis Accelerat.     -17.0477        0.00000       -2.03282    
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.     -17.0477        0.00000       -2.03282    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.     -17.0477        0.00000       -2.03282    
----------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Lifting-Body Aircraft Landing Phase (Stability Axis)                             
! This Lifting-Body Aircraft Model is created by the Trim program at t=1810 sec trajectory time.
! It uses all 7 aero-surfaces for flight control. The output rates are in the Stability-Axis and the
! "Turn-Coordination" flag is turned-on. It means the turn-coordination terms will be included in the
! model. This model will be used to create pitch and lateral LQR design state-space systems.
!
Stability Output, Attitude=Euler Angles, With Turn Coordination
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   527.950       32.1740      0.208960E+08
Moments and products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   10800.0       43300.0       49600.0       0.00000       433.000      0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -17.0420       0.00000      -2.03400    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.433000       466.400       199.449       8694.90    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  -1.68420      -7.86800       0.00000      -31.4990    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   8.53100       0.00000      0.178947E-01   0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00000      -33.1330       0.00000       0.00000     -0.800000E-02  0.100000E-02
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust         45.0000      90.0000                                             
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   300.000       34.0000       15.0000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -16.2000       0.00000      -2.10000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.279368E-01 -0.628772E-02 -0.835307E-05   0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000     -0.756440E-02   0.00000     -0.841975E-05   0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.276936     -0.387948E-01   0.00000       0.00000       0.00000       0.00000     -0.149593E-03
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000     -0.109128E-01   0.00000     -0.603260      0.667660      0.313128E-04
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.795947E-02 -0.359662E-02   0.00000     -0.190200E-04 -0.190100     -0.265926E-04   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000      0.212280E-02   0.00000      0.301090     -0.993980      0.409249E-05

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  7   NO TWD  

Control Surface No:  1                                                                     Left Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -3.7           30.0000      -30.0000       45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.169400E-02   0.00000     -0.871020E-02 -0.916866E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000      -7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.202527E-03  0.167813E-02 -0.232000E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.163713E-02 -0.896933E-03 -0.131907E-02   0.00000       0.00000       0.00000    
Control Surface No:  2                                                                     Right Elevon   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -3.7           30.0000      -30.0000      -45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.169400E-02   0.00000     -0.871020E-02 -0.916866E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000       7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.202527E-03 -0.167813E-02 -0.232000E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.163713E-02 -0.896933E-03  0.131907E-02   0.00000       0.00000       0.00000    
Control Surface No:  3                                                                     Vert Rudder    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   0.0           30.0000      -30.0000       90.0000       2.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       5.80000       12.0000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.170533E-01   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -33.0000       0.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.311647E-03  0.152260E-02  0.583573E-04   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.103913E-03  0.120000E-04 -0.114373E-02   0.00000       0.00000       0.00000    
Control Surface No:  4                                                                     BFlap Up-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -14.0          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.376000E-02   0.00000     -0.940133E-02  0.579333E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.363793E-03 -0.250240E-03 -0.115020E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.448873E-03 -0.126773E-03  0.268613E-04   0.00000       0.00000       0.00000    
Control Surface No:  5                                                                     BFlap Up-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -14.0          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.376000E-02   0.00000     -0.940133E-02  0.579333E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.363793E-03  0.250240E-03 -0.115020E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.448873E-03 -0.126773E-03 -0.268613E-04   0.00000       0.00000       0.00000    
Control Surface No:  6                                                                     BFlap Lo-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   15.0          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.405997E-03   0.00000     -0.519187E-02 -0.484100E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.908333E-03  0.594487E-03 -0.129520E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.308907E-03 -0.375247E-03 -0.193687E-03   0.00000       0.00000       0.00000    
Control Surface No:  7                                                                     BFlap Lo-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   15.0          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.405997E-03   0.00000     -0.519187E-02 -0.484100E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.908333E-03 -0.594487E-03 -0.129520E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.308907E-03 -0.375247E-03  0.193687E-03   0.00000       0.00000       0.00000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  3
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  X-axis Accelerat.     -17.0477        0.00000       -2.03282    
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.     -17.0477        0.00000       -2.03282    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.     -17.0477        0.00000       -2.03282    
----------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Lifting-Body Aircraft Landing Phase (Robust Analysis with 60 Uncert)
! This Lifting-Body Aircraft Model is created by the Trim program at t=1810 sec trajectory time.
! The rates are in body axes, similar to the first model, but it includes 60 additional inputs
! and outputs representing parameter variations due to uncertainties. It is used for robustness
! analysis using mu.
!
Body Axes Output, Attitude=Euler Angles
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   527.950       32.1740      0.208960E+08
Moments and products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   10800.0       43300.0       49600.0       0.00000       433.000      0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -17.0420       0.00000      -2.03400    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.433000       466.400       199.449       8694.90    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  -1.68420      -7.86800       0.00000      -31.4990    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   8.53100       0.00000      0.178947E-01   0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00000      -33.1330       0.00000       0.00000     -0.800000E-02  0.100000E-02
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust         45.0000      90.0000                                             
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   300.000       34.0000       15.0000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -16.2000       0.00000      -2.10000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.279368E-01 -0.628772E-02 -0.835307E-05   0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000     -0.756440E-02   0.00000     -0.841975E-05   0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.276936     -0.387948E-01   0.00000       0.00000       0.00000       0.00000     -0.149593E-03
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000     -0.109128E-01   0.00000     -0.603260      0.667660      0.313128E-04
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.795947E-02 -0.359662E-02   0.00000     -0.190200E-04 -0.190100     -0.265926E-04   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000      0.212280E-02   0.00000      0.301090     -0.993980      0.409249E-05

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  7   NO TWD  

Control Surface No:  1                                                                     Left Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -3.7           30.0000      -30.0000       45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.169400E-02   0.00000     -0.871020E-02 -0.916866E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000      -7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.202527E-03  0.167813E-02 -0.232000E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.163713E-02 -0.896933E-03 -0.131907E-02   0.00000       0.00000       0.00000    
Control Surface No:  2                                                                     Right Elevon   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -3.7           30.0000      -30.0000      -45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.169400E-02   0.00000     -0.871020E-02 -0.916866E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000       7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.202527E-03 -0.167813E-02 -0.232000E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.163713E-02 -0.896933E-03  0.131907E-02   0.00000       0.00000       0.00000    
Control Surface No:  3                                                                     Vert Rudder    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   0.0           30.0000      -30.0000       90.0000       2.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       5.80000       12.0000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.170533E-01   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -33.0000       0.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.311647E-03  0.152260E-02  0.583573E-04   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.103913E-03  0.120000E-04 -0.114373E-02   0.00000       0.00000       0.00000    
Control Surface No:  4                                                                     BFlap Up-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -14.0          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.376000E-02   0.00000     -0.940133E-02  0.579333E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.363793E-03 -0.250240E-03 -0.115020E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.448873E-03 -0.126773E-03  0.268613E-04   0.00000       0.00000       0.00000    
Control Surface No:  5                                                                     BFlap Up-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -14.0          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.376000E-02   0.00000     -0.940133E-02  0.579333E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.363793E-03  0.250240E-03 -0.115020E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.448873E-03 -0.126773E-03 -0.268613E-04   0.00000       0.00000       0.00000    
Control Surface No:  6                                                                     BFlap Lo-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   15.0          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.405997E-03   0.00000     -0.519187E-02 -0.484100E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.908333E-03  0.594487E-03 -0.129520E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.308907E-03 -0.375247E-03 -0.193687E-03   0.00000       0.00000       0.00000    
Control Surface No:  7                                                                     BFlap Lo-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   15.0          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.405997E-03   0.00000     -0.519187E-02 -0.484100E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.908333E-03 -0.594487E-03 -0.129520E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.308907E-03 -0.375247E-03  0.193687E-03   0.00000       0.00000       0.00000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  3
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  X-axis Accelerat.     -17.0477        0.00000       -2.03282    
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.     -17.0477        0.00000       -2.03282    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.     -17.0477        0.00000       -2.03282    

Parameter Uncertainties Data
Uncertainties at Mach=0.43, Alpha=10
-------------------------------------------------------------------------------------------------------------------------------------------------------                                                                  
UNCERTAIN PARAMETER VARIATIONS FROM NOMINAL ......                                                                    
Uncertainties at Mach=0.43, Alpha=10
! The following data are not actual vehicle parameters but they represent uncertainties
! of the corresponding parameters in the vehicle data. The title above these comments                                                                                
! defines the flight condition where they apply. The uncertainty values represent a +ve 
! or -ve additive variation above or below the nominal values in the vehicle data above.
                                                                                                                                                                                                                            
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  0.0          0.0          0.0                                                                                           
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  50.0        200.0        200.0         0.0   0.0    0.0                                                       
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  0.5          0.15         0.0                                                                                                 
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.0          0.0          0.0          0.0                                                                                  
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  0.0          0.0          0.0          0.0                                                                                    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  2.0          1.0          0.0          0.0                                                                        
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   : -0.0          0.0          0.0          0.0   0.0    0.0                                                       
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.02,   0.001,    0.0,   0.0,     0.0,     0.0,    0.0                                                                         
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,    0.002,    0.0,   0.0,     0.0,     0.0,    0.0                                                                         
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  0.03,   0.002,    0.0,   0.0,     0.0,     0.0,    0.0                                            
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,    0.0015,   0.0,   0.05,    0.03,    0.0                                                                                 
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.003,  0.0005,   0.0,   0.0,     0.1,     0.0,    0.0                                                                         
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,    0.0007,   0.0,   0.05,    0.06,    0.0                                                                                 
                                                                                                                                                                                                                            
Number of Control Surfaces, (Variations from Nominal Aero Parameters)                    :  7                                                                                                    
                                                                                                                                                                                                                            
Control Surface No:  1                                                                     Left Elevon    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0       
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0001       0.0003       0.0002        0.0          0.0          0.0  
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0005       0.00008      0.0004        0.0          0.0          0.0    
Control Surface No:  2                                                                     Right Elevon   
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0       
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0001       0.0003       0.0002        0.0          0.0          0.0  
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0005       0.00008      0.0004        0.0          0.0          0.0    
Control Surface No:  3                                                                     Vert Rudder    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0       
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0          0.0005       0.0           0.0          0.0          0.0  
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.00005      0.0          0.0003        0.0          0.0          0.0    
Control Surface No:  4                                                                     BFlap Up-Lft   
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0       
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00015      0.0002       0.0004        0.0          0.0          0.0  
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0002       0.00006      0.0001        0.0          0.0          0.0    
Control Surface No:  5                                                                     BFlap Up-Rht   
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0       
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00015      0.0002       0.0004        0.0          0.0          0.0  
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0002       0.00006      0.0001        0.0          0.0          0.0    
Control Surface No:  6                                                                     BFlap Lo-Lft   
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0       
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0001       0.0002       0.0004        0.0          0.0          0.0  
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0001       0.0001       0.00006       0.0          0.0          0.0    
Control Surface No:  7                                                                     BFlap Lo-Rht   
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0       
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0001       0.0002       0.0004        0.0          0.0          0.0  
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0001       0.0001       0.00006       0.0          0.0          0.0    
-----------------------------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Lifting-Body Aircraft Near Landing, Simulation Model
Lifting-Body Aircraft Landing Phase (Simul Model)  
! This model is used for simulations. It is the same as the previous model with one
! additional output. The output vector is augmented to include the change in 
! vehicle velocity (dV), which is state # 10.
!
NEW SYSTEM OUTPUTS FROM PREVIOUS SYSTEM OUTPUTS/ STATES/ DERIVATIVES
From Old System Output:    1                        Roll Attitude    (phi)  (radians)                                      
From Old System Output:    2                        Roll Rate        (p-body)  (rad/sec)                                      
From Old System Output:    3                        Pitch Attitude    (theta)  (radians)                                      
From Old System Output:    4                        Pitch Rate       (q-body)  (rad/sec)                                      
From Old System Output:    5                        Yaw Attitude     (psi)     (radians)                                      
From Old System Output:    6                        Yaw Rate         (r-body)  (rad/sec)                                      
From Old System Output:    7                        Angle of attack   (alfa)   (radians)                                      
From Old System Output:    8                        Angle of Sideslip  (beta)  (radians)                                      
From Old System Output:    9                        Change in Altitude (delta-h)  (feet)                                        
From Old System Output:   10                        Forward Accelerat. (V-dot)  (ft/sec)                                      
From Old System Output:   11                        Cross Range Velocity (Vcr) (ft/sec)                                      
From Old System Output:   12                        CG Acceleration along X axis, (ft/sec^2)                                      
From Old System Output:   13                        CG Acceleration along Y axis, (ft/sec^2)                                      
From Old System Output:   14                        CG Acceleration along Z axis, (ft/sec^2)                                      
From Old System State :   10                        Change in Velocity (delta-V)(ft/sec)                                      
----------------------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic for Lifting-Body Aircraft Landing Phase                                                                               Title
! The following mixing logic matrix combines the 7 aero-surfaces together to control the 
! vehicle in 4 directions roll, pitch, yaw, and forward Ax accelerations (using the Speed-Brake)
! It translates the 4 FCS demands to surface deflection commands. It is saved in KmixM0p4a.mat
!
KmixM0p4a                                                                                                                          Matrix Name
Lifting-Body Aircraft Landing Phase (Simul Model)                                                                                  Title of Vehicle Data
P-dot Roll  Acceleration About X Axis                                                                                              3-rotational dofs
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
Ax  Forward Acceleration Demand Along X Axis                                                                                       1-translation dof
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Lifting-Body Aircraft Landing Phase Pitch Design Model                                         
Lifting-Body Aircraft Landing Phase (Stability Axis)                                                      
! Extract the Pitch axis subsystem from the stability-axis model to be used for 
! Pitch LQR control design. It includes all 7 aero-surface control inputs.
! It includes the Velocity state in the output vector.
NEW SYSTEM OUTPUTS FROM PREVIOUS SYSTEM OUTPUTS/ STATES/ DERIVATIVES
From Old System Output:    3                        Pitch Attitude    (theta)  (radians)                                      
From Old System Output:    4                        Pitch Rate        (q -body)(rad/sec)                                      
From Old System Output:    7                        Angle of attack   (alfa)   (radians)                                      
From Old System Output:    9                        Change in Altitude (delta-h)  (feet)                                        
From Old System State :   10                        Change in Velocity (delta-V)(ft/sec)                                      
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1   2   3   4   5   6   7
Extract States :   3   4   7   9  10  
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Lifting-Body Aircraft Landing Phase Lateral Design Model
Lifting-Body Aircraft Landing Phase (Stability Axis)                                                      
! Extract the Lateral axis subsystem from the stability-axis model to be used for 
! Lateral LQR control design. It includes all 7 aero-surface control inputs.
! The state-vector is (p, r, beta)
!
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1  2  3  4  5  6  7
Extract States :   2  6  8
Extract Outputs:   2  6  8
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Lifting-Body Aircraft Near Landing, Pitch Robust Analysis (28 Uncs)
Lifting-Body Aircraft Landing Phase (Robust Analysis with 60 Uncert)  
! This pitch model is extracted from the full uncertainties model. It is used for 
! Robustness Analysis in pitch. Only the 28 pitch uncertainties are included.
!
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1  2  3  4  5  6  7 10 12 13 15 16 17 22 24 26 28 30 32 34 36 38 40 45 47 49 51 53 55 57 59 61 63 65 67
Extract States :   3  4  7  9 10
Extract Outputs:   3  4  7  9 10 14    16 18 19 21 22 23 28 30 32 34 36 38 40 42 44 46 51 53 55 57 59 61 63 65 67 69 71 73
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Lifting-Body Aircraft Near Landing, Lateral Robust Analysis (32 Uncs)
Lifting-Body Aircraft Landing Phase (Robust Analysis with 60 Uncert)  
! This lateral model is extracted from the full uncertainties model. It is used for 
! Robustness Analysis in lateral. Only the 32 lateral uncertainties are included.
!
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1  2  3  4  5  6  7  9 11 14 18 19 20 21 23 25 27 29 31 33 35 37 39 41 42 43 44 46 48 50 52 54 56 58 60 62 64 66 68
Extract States :   1  2  6  8
Extract Outputs:   1  2  6  8 11 13    15 17 20 24 25 26 27 29 31 33 35 37 39 41 43 45 47 48 49 50 52 54 56 58 60 62 64 66 68 70 72 74
----------------------------------------------------------------------------------------------------------------------------------------------------------------
The following data-sets convert the systems and matrices from the "Land_M0,4.Qdr" file for Matlab analysis
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lifting-Body Aircraft Near Landing, Simulation Model                                                                                    
System
vehicle_sim
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lifting-Body Aircraft Landing Phase Pitch Design Model                                                                                    
System
Pitch_des
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lifting-Body Aircraft Landing Phase Lateral Design Model                                                                                    
System
Later_des
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic for Lifting-Body Aircraft Landing Phase            
Matrix KmixM0p4a
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lifting-Body Aircraft Near Landing, Pitch Robust Analysis (28 Uncs)                                                                                    
System
pitch_unc
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lifting-Body Aircraft Near Landing, Lateral Robust Analysis (32 Uncs)                                                                                    
System
later_unc
----------------------------------------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
