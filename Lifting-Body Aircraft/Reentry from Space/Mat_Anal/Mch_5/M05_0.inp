BATCH MODE INSTRUCTIONS ...............                                                             
Batch for analyzing the Transitioning Phase of the Lifting-Body Vehicle at t=1265 sec
! This batch set creates dynamic models for control design and simulations of the lifting-body 
! vehicle during the early re-entry phase where Qbar is very low. It creates a model in the 
! body axis for simulation purposes. It creates also two additional models (pitch and lateral)
! for control design for using the LQR method. All 7 aero-surfaces are used to control the 
! vehicle. 
!
Flight Vehicle   : Lifting-Body Aircraft Hypersonic Descent from Space /T= 1265 sec (Simul Model)
Flight Vehicle   : Lifting-Body Aircraft Hypersonic Descent from Space /T= 1265 sec (Stability Axis)
Mixing Matrix    : Mixing Logic Lifting-Body Aircraft Hypersonic Descent from Space /T= 1265 sec
System Modificat : Lifting-Body Aircraft Hypersonic Pitch Design Model
System Modificat : Lifting-Body Aircraft Hypersonic Lateral Design Model
To Matlab Format : Lifting-Body Aircraft Hypersonic Descent from Space /T= 1265 sec (Simul Model)
To Matlab Format : Lifting-Body Aircraft Hypersonic Pitch Design Model
To Matlab Format : Lifting-Body Aircraft Hypersonic Lateral Design Model
To Matlab Format : Mixing Logic Lifting-Body Aircraft Hypersonic Descent from Space /T= 1265 sec
----------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Lifting-Body Aircraft Hypersonic Descent from Space /T= 1265 sec (Simul Model)
! This Lifting-Body Aircraft Model is created by the Trim program at t=1265 sec trajectory time.
! It uses all 7 aero-surfaces for flight control. The output rates are in the Body-Axis. It will 
! be used for simulations in Simulink
Body Axes Output, Attitude=Euler Angles
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   527.950       32.1740      0.208960E+08
Moments and products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   10800.0       43300.0       49600.0       0.00000       433.000      0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -17.0420       0.00000      -2.03400    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   4.88200       5320.70       142.005       128416.    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  -12.0600      -6.90600       0.00000      -32.8180    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   10.6250       0.00000     -0.539989E-02   0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0           9.32300       0.00000       0.00000     -0.130000E-01   0.00000    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust         45.0000      90.0000                                             
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   300.000       34.0000       15.0000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -16.2000       0.00000      -2.10000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.649159E-01 -0.142027E-02   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000     -0.947500E-02   0.00000     -0.585301E-05   0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.407089     -0.389329E-01   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000     -0.159218E-01   0.00000     -0.611150      0.670940     -0.414939E-05
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.871644E-02 -0.139697E-02   0.00000     -0.190008E-05 -0.198880       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000      0.227540E-02   0.00000      0.272690      -1.01210      0.561966E-05

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  7   NO TWD  

Control Surface No:  1                                                                     Left Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   4.6           30.0000       30.0000       45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.166900E-02   0.00000     -0.572927E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000      -7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.636013E-03  0.120667E-02 -0.787467E-03   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.475733E-03 -0.299820E-03 -0.134947E-02   0.00000       0.00000       0.00000    
Control Surface No:  2                                                                     Right Elevon   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   4.6           30.0000       30.0000      -45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.166900E-02   0.00000     -0.572927E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000       7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.636013E-03 -0.120667E-02 -0.787467E-03   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.475733E-03 -0.299820E-03  0.134947E-02   0.00000       0.00000       0.00000    
Control Surface No:  3                                                                     Vert Rudder    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg): -0.0            30.0000       30.0000       90.0000       2.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       5.80000       12.0000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.869800E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -33.0000       0.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.220393E-03  0.108293E-02 -0.231133E-03   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.170360E-03 -0.690000E-04 -0.769067E-03   0.00000       0.00000       0.00000    
Control Surface No:  4                                                                     BFlap Up-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -5.67          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.607293E-03   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.775200E-03  0.180960E-03 -0.202153E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.718200E-03 -0.541953E-03 -0.249527E-03   0.00000       0.00000       0.00000    
Control Surface No:  5                                                                     BFlap Up-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -5.67          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.607293E-03   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.775200E-03 -0.180960E-03 -0.202153E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.718200E-03 -0.541953E-03  0.249527E-03   0.00000       0.00000       0.00000    
Control Surface No:  6                                                                     BFlap Lo-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   3.34          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.854333E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.884200E-03  0.383840E-03 -0.205867E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.376767E-03 -0.730200E-03 -0.248113E-03   0.00000       0.00000       0.00000    
Control Surface No:  7                                                                     BFlap Lo-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   3.34          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.854333E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.884200E-03 -0.383840E-03 -0.205867E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.376767E-03 -0.730200E-03  0.248113E-03   0.00000       0.00000       0.00000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  3
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  X-axis Accelerat.     -17.0477        0.00000       -2.03282    
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.     -17.0477        0.00000       -2.03282    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.     -17.0477        0.00000       -2.03282    
----------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Lifting-Body Aircraft Hypersonic Descent from Space /T= 1265 sec (Stability Axis)                             
! This Lifting-Body Aircraft Model is created by the Trim program at t=3000 sec trajectory time.
! It uses all 7 aero-surfaces for flight control. The output rates are in the Stability-Axis and the
! "Turn-Coordination" flag is turned-on. That is, the turn-coordination terms will be included in the
! model. This model will be used to create the pitch and lateral LQR design state-space systems.
!
Stability Output, Attitude=Euler Angles, With Turn Coordination
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   527.950       32.1740      0.208960E+08
Moments and products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   10800.0       43300.0       49600.0       0.00000       433.000      0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -17.0420       0.00000      -2.03400    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   4.88200       5320.70       142.005       128416.    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  -12.0600      -6.90600       0.00000      -32.8180    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   10.6250       0.00000     -0.539989E-02   0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0           9.32300       0.00000       0.00000     -0.130000E-01   0.00000    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust         45.0000      90.0000                                             
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   300.000       34.0000       15.0000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -16.2000       0.00000      -2.10000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.649159E-01 -0.142027E-02   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000     -0.947500E-02   0.00000     -0.585301E-05   0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.407089     -0.389329E-01   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000     -0.159218E-01   0.00000     -0.611150      0.670940     -0.414939E-05
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.871644E-02 -0.139697E-02   0.00000     -0.190008E-05 -0.198880       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000      0.227540E-02   0.00000      0.272690      -1.01210      0.561966E-05

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  7   NO TWD  

Control Surface No:  1                                                                     Left Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   4.6           30.0000       30.0000       45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.166900E-02   0.00000     -0.572927E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000      -7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.636013E-03  0.120667E-02 -0.787467E-03   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.475733E-03 -0.299820E-03 -0.134947E-02   0.00000       0.00000       0.00000    
Control Surface No:  2                                                                     Right Elevon   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   4.6           30.0000       30.0000      -45.0000       5.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       1.70000       8.50000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.166900E-02   0.00000     -0.572927E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -28.0000       7.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.636013E-03 -0.120667E-02 -0.787467E-03   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.475733E-03 -0.299820E-03  0.134947E-02   0.00000       0.00000       0.00000    
Control Surface No:  3                                                                     Vert Rudder    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg): -0.0            30.0000       30.0000       90.0000       2.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       5.80000       12.0000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.869800E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -33.0000       0.00000      -5.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.220393E-03  0.108293E-02 -0.231133E-03   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.170360E-03 -0.690000E-04 -0.769067E-03   0.00000       0.00000       0.00000    
Control Surface No:  4                                                                     BFlap Up-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -5.67          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.607293E-03   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.775200E-03  0.180960E-03 -0.202153E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.718200E-03 -0.541953E-03 -0.249527E-03   0.00000       0.00000       0.00000    
Control Surface No:  5                                                                     BFlap Up-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -5.67          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.607293E-03   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000      -3.50000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.775200E-03 -0.180960E-03 -0.202153E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.718200E-03 -0.541953E-03  0.249527E-03   0.00000       0.00000       0.00000    
Control Surface No:  6                                                                     BFlap Lo-Lft   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   3.34          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.854333E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000      -4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.884200E-03  0.383840E-03 -0.205867E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.376767E-03 -0.730200E-03 -0.248113E-03   0.00000       0.00000       0.00000    
Control Surface No:  7                                                                     BFlap Lo-Rht   
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   3.34          10.0000      -10.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   1.00000      0.300000       1.00000       2.10000       7.20000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.854333E-02   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -32.0000       4.00000     -0.500000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.884200E-03 -0.383840E-03 -0.205867E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.376767E-03 -0.730200E-03  0.248113E-03   0.00000       0.00000       0.00000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  3
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  X-axis Accelerat.     -17.0477        0.00000       -2.03282    
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.     -17.0477        0.00000       -2.03282    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.     -17.0477        0.00000       -2.03282    
----------------------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic Lifting-Body Aircraft Hypersonic Descent from Space /T= 1265 sec                                                      Title
! Mixing Logic Matrix for the Lifting-Body Aircraft during Descent at T=1265                                                       Comments
KmixM5a                                                                                                                            Matrix Name
Lifting-Body Aircraft Hypersonic Descent from Space /T= 1265 sec (Simul Model)                                                     Vehicle Data
P-dot Roll  Acceleration About X Axis                                                                                              3-rotational dofs
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
----------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Lifting-Body Aircraft Hypersonic Pitch Design Model                                         
Lifting-Body Aircraft Hypersonic Descent from Space /T= 1265 sec (Stability Axis)                                                      
! Extract the Pitch axis subsystem from the stability-axis model to be used for 
! Pitch LQR control design. Include all 7 aero-surface control inputs.
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1  2  3  4  5  6  7
Extract States :   3  4  7  
Extract Outputs:   3  4  7
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Lifting-Body Aircraft Hypersonic Lateral Design Model
Lifting-Body Aircraft Hypersonic Descent from Space /T= 1265 sec (Stability Axis)                                                      
! Extract the Lateral axis subsystem from the stability-axis model to be used for 
! Lateral LQR control design. Include all 7 aero-surface control inputs.
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1  2  3  4  5  6  7
Extract States :   2  6  8
Extract Outputs:   2  6  8
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lifting-Body Aircraft Hypersonic Descent from Space /T= 1265 sec (Simul Model)                                                                                    
System
vehicle_sim
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lifting-Body Aircraft Hypersonic Pitch Design Model                                                                                    
System
Pitch_des
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lifting-Body Aircraft Hypersonic Lateral Design Model                                                                                    
System
Later_des
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic Lifting-Body Aircraft Hypersonic Descent from Space /T= 1265 sec            
Matrix KmixM5a
----------------------------------------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
